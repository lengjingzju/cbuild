inherit externalsrc
EXTERNALSRC = "${ENV_TOP_DIR}/examples/test-app"
EXTERNALSRC_BUILD = "${ENV_TOP_DIR}/examples/test-app"

