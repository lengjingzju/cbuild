inherit externalsrc
EXTERNALSRC = "${ENV_TOP_DIR}/examples/test-mod2"
EXTERNALSRC_BUILD = "${ENV_TOP_DIR}/examples/test-mod2"

