inherit externalsrc
EXTERNALSRC = "${ENV_TOP_DIR}/examples/test-app2"
EXTERNALSRC_BUILD = "${ENV_TOP_DIR}/examples/test-app2"

