export ENV_TOP_DIR
export CONF_PATH = "${STAGING_BINDIR_NATIVE}"
export OUT_PATH = "${WORKDIR}/build"
export ENV_INS_ROOT = "${WORKDIR}/image"
export ENV_DEP_ROOT = "${WORKDIR}/recipe-sysroot"
export ENV_BUILD_MODE
