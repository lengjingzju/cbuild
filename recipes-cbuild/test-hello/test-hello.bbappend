inherit externalsrc
EXTERNALSRC = "${ENV_TOP_DIR}/test-mod/test_hello"
EXTERNALSRC_BUILD = "${ENV_TOP_DIR}/test-mod/test_hello"

