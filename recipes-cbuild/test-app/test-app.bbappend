inherit externalsrc
EXTERNALSRC = "${ENV_TOP_DIR}/test-app"
EXTERNALSRC_BUILD = "${ENV_TOP_DIR}/test-app"

