inherit externalsrc
EXTERNALSRC = "${ENV_TOP_DIR}/test-mod/test_hello_add"
EXTERNALSRC_BUILD = "${ENV_TOP_DIR}/test-mod/test_hello_add"

